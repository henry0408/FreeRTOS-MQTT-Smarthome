# Keil uVision project F103_Moduel.uvprojx, settings and files
target F103_Moduel (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: F103_Moduel +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\ModuleDrivers;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;..\smartdevice\cal;..\smartdevice\input;..\smartdevice\kal;..\smartdevice\unittest;..\smartdevice\device;..\smartdevice\device\display;..\smartdevice\config;..\smartdevice\fonts;..\smartdevice\text;..\smartdevice\text\encoding;..\smartdevice\net;..\smartdevice\device\uart;..\smartdevice\net\at_command;..\smartdevice\smarthome;..\smartdevice\time;..\NET\CJSON;..\NET\MQTT;..\NET\onenet\src;..\NET\onenet\inc
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group ModuleDrivers
    ../ModuleDrivers/: driver_usart.c ring_buffer.c driver_key.c driver_fan.c driver_fan.h driver_i2c.c driver_i2c.h driver_key.h driver_led.c driver_oled.c driver_led.h driver_oled.h driver_usart.h ring_buffer.h driver_dht11.h driver_dht11.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group kal
    ../smartdevice/kal/: kal_fan_device.c kal_fan_device.h kal_led_device.c kal_led_device.h kal_oled_device.c kal_oled_device.h kal_gpio_input.c kal_gpio_input.h kal_dht11_device.c kal_dht11_device.h
  group cal
    ../smartdevice/cal/: cal_fan_device.c cal_fan_device.h cal_led_device.c cal_led_device.h cal_oled_device.c cal_oled_device.h cal_gpio_input.c cal_gpio_input.h cal_dht11_device.c cal_dht11_device.h
  group input
    ../smartdevice/input/: input_buffer.c input_buffer.h input_system.c input_system.h net_input.c net_input.h gpio_input.c gpio_input.h
  group device
    ../smartdevice/device/: fan_device.c fan_device.h led_device.c led_device.h dht11_device.c dht11_device.h
  group display
    ../smartdevice/device/display/: display_system.c display_system.h oled_device.c oled_device.h display_device.c display_device.h
  group config
    ../smartdevice/config/: config.h
  group fonts
    ../smartdevice/fonts/: ascii_font.c ascii_font.h font_system.c font_system.h font_manager.c font_manager.h
  group text
    ../smartdevice/text/: show_text.c show_text.h
  group net
    ../smartdevice/net/: esp8266.c esp8266.h net_system.c net_system.h at_command.c at_command.h uart_device.c uart_device.h
  group smarthome
    ../smartdevice/smarthome/: message.c message.h smarthome.c smarthome.h
  group unittest
    ../smartdevice/unittest/: display_test.c display_test.h fan_test.c fan_test.h input_test.c input_test.h led_test.c led_test.h net_test.c net_test.h net_test2.c net_test2.h text_test.c text_test.h mqtt_test1.c mqtt_test1.h
  group time
    ../smartdevice/time/: time.c time.h
  group encoding
    ../smartdevice/text/encoding/: encoding.c encoding.h
  group OneNET
    ../NET/onenet/src/: base64.c hmac_sha1.c onenet.c
    ../NET/onenet/inc/: base64.h hmac_sha1.h onenet.h
  group net_protocol
    ../NET/MQTT/: Common.h MqttKit.c MqttKit.h
  group CJSON
    ../NET/CJSON/: cJSON.c cJSON.h
software components: CMSIS:CORE 4.3.0
